FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:simpleboot = " file://simpleboot.cfg "

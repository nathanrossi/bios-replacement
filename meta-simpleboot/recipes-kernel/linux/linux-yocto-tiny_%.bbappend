# TODO
COMPATIBLE_MACHINE:common-x86-64 = ".*"
KMACHINE:common-x86-64 = "qemux86-64"
